LICENSE = "GPL-3.0-only & LGPL-3.0-only & BSD-3-Clause"
LIC_FILES_CHKSUM = "file://package.xml;beginline=16;endline=18;md5=9b511d4c606b1a23e454d3260818d003"
