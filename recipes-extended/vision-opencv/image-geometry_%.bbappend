LICENSE = "Apache-2.0 & BSD-3-Clause"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=12;md5=765592feee72bbe5ef65c6e65b6d5895"
