FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://docker-config.cfg"